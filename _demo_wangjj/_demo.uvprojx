# Keil uVision project _demo.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: _demo +hex
  c flags: OneElfS=1 v6Lang=3 v6LangP=3 wLevel=1
  c include: .\include_stm32f103_wangjj
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source Group 1
    ./: main.c
  group include
    ./include_stm32f103_wangjj/: GPIO_wangjj.c GPIO_wangjj.h SYSTEM_wangjj.c SYSTEM_wangjj.h
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.0
